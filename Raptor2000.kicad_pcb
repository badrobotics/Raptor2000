# Repository badrobotics/Raptor2000

## KiCad design Raptor2000.kicad_pcb

Schematic: Raptor2000.sch

Parts:
H101, H102, H103, H104: MountingHole; MountingHole_3.2mm_M3

Schematic: memory.sch, Raptor2000

Parts:
C201, C202, C203, C204, C205, C206, C207, C208: 0.1u; C_0603_1608Metric
R201: 0; R_0603_1608Metric
R202, R204: DNP; R_0603_1608Metric
R203: 1M; R_0603_1608Metric
R205: 10k; R_0603_1608Metric
U201: IS42S16400J-xC; TSOP-II-54_22.2x10.16mm_P0.8mm
U202: TC58CVG2S0HRAIG; WSON-8-1EP_3.4x4.3mm_P1.27mm

Connections:
+3V3: C201.1, C202.1, C203.1, C204.1, C205.1, C206.1, C207.1, C208.1, R202.1, R204.1, R205.1, U201.1 (VDD), U201.3 (VDDQ), U201.9 (VDDQ), U201.14 (VDD), U201.27 (VDD), U201.43 (VDDQ), U201.49 (VDDQ), U202.8; also elsewhere on the board
/Memory/CLK: R201.1, U201.38 (CLK)
/Memory/EPI0S0: U201.2 (DQ0), U201.23 (A0); also elsewhere on the board
/Memory/EPI0S1: U201.4 (DQ1), U201.24 (A1); also elsewhere on the board
/Memory/EPI0S2: U201.5 (DQ2), U201.25 (A2); also elsewhere on the board
/Memory/EPI0S3: U201.7 (DQ3), U201.26 (A3); also elsewhere on the board
/Memory/EPI0S4: U201.8 (DQ4), U201.29 (A4); also elsewhere on the board
/Memory/EPI0S5: U201.10 (DQ5), U201.30 (A5); also elsewhere on the board
/Memory/EPI0S6: U201.11 (DQ6), U201.31 (A6); also elsewhere on the board
/Memory/EPI0S7: U201.13 (DQ7), U201.32 (A7); also elsewhere on the board
/Memory/EPI0S8: U201.33 (A8), U201.42 (DQ8); also elsewhere on the board
/Memory/EPI0S9: U201.34 (A9), U201.44 (DQ9); also elsewhere on the board
/Memory/EPI0S10: U201.22 (A10), U201.45 (DQ10); also elsewhere on the board
/Memory/EPI0S11: U201.35 (A11), U201.47 (DQ11); also elsewhere on the board
/Memory/EPI0S12: U201.36 (A12), U201.48 (DQ12); also elsewhere on the board
/Memory/EPI0S13: U201.20 (BA0), U201.50 (DQ13); also elsewhere on the board
/Memory/EPI0S14: U201.21 (BA1), U201.51 (DQ14); also elsewhere on the board
/Memory/EPI0S15: U201.53 (DQ15); also elsewhere on the board
/Memory/EPI0S16: U201.15 (DQML); also elsewhere on the board
/Memory/EPI0S17: U201.39 (DQMH); also elsewhere on the board
/Memory/EPI0S18: U201.17 (~CAS); also elsewhere on the board
/Memory/EPI0S19: U201.18 (~RAS); also elsewhere on the board
/Memory/EPI0S28: U201.16 (~WE); also elsewhere on the board
/Memory/EPI0S31: R201.2; also elsewhere on the board
/Memory/FLASH_DAT0: U202.5; also elsewhere on the board
/Memory/FLASH_DAT1: U202.2; also elsewhere on the board
/Memory/FLASH_DAT2: R204.2, U202.3; also elsewhere on the board
/Memory/FLASH_DAT3: R202.2, U202.7; also elsewhere on the board
/Memory/FLASH_SCLK: R203.1, U202.6; also elsewhere on the board
/TM4C129/SSI2Fss: R205.2, U202.1; also elsewhere on the board
GND: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, R203.2, U201.6 (GNDQ), U201.12 (GNDQ), U201.28 (GND), U201.41 (GND), U201.46 (GNDQ), U201.52 (GNDQ), U201.54 (GND), U202.4; also elsewhere on the board

Notes on the sheet:
EPI Traces must have a capacitance of < 35pF

Schematic: connectors.sch, Raptor2000

Parts:
J301: ET60T-000-3-08-D04-x-R1-S-x; Conn_Samtec_ET60T-000-3-08-D-4-x-R1-S-x

Connections:
+3V3: J301.1, J301.P01; also elsewhere on the board
+5V: J301.P02; also elsewhere on the board
+BATT: J301.P03; also elsewhere on the board
/Connectors/JTAG_TCK: J301.12; also elsewhere on the board
/Connectors/JTAG_TDI: J301.10; also elsewhere on the board
/Connectors/JTAG_TDO: J301.9; also elsewhere on the board
/Connectors/JTAG_TMS: J301.11; also elsewhere on the board
/Connectors/USB_OTG_VBUS: J301.20; also elsewhere on the board
/Connectors/~ENABLE: J301.15; also elsewhere on the board
/Connectors/~INHIBIT: J301.16; also elsewhere on the board
/Connectors/~SYSRESET: J301.14; also elsewhere on the board
/TM4C129/ETH_RXI_N: J301.21; also elsewhere on the board
/TM4C129/ETH_RXI_P: J301.22; also elsewhere on the board
/TM4C129/ETH_TXO_N: J301.23; also elsewhere on the board
/TM4C129/ETH_TXO_P: J301.24; also elsewhere on the board
/TM4C129/USB_D_N: J301.17; also elsewhere on the board
/TM4C129/USB_D_P: J301.18; also elsewhere on the board
/TM4C129/USB_ID: J301.19; also elsewhere on the board
GND: J301.P04; also elsewhere on the board

Parts:
C401, C402, C411, C412: 12p; C_0603_1608Metric
C403, C405, C406, C407, C409, C413, C414, C415: 0.1u; C_0603_1608Metric
C404: 1.0u; C_0603_1608Metric
C408, C416: 2.2u; C_0603_1608Metric
D401, D402, D403, D404, D405, D406, D407: LED; LED_0805_2012Metric
R1: DNP; R_0603_1608Metric
R2: 0; R_0603_1608Metric
R402, R406: 100; R_0603_1608Metric
R403: 2k; R_0603_1608Metric
R404: 4.87k 1%; R_0603_1608Metric
R405: 10k; R_0603_1608Metric
R407, R408, R413, R414, R415, R416, R417: 330; R_0603_1608Metric
R409, R410, R411, R412: 49.9; R_0603_1608Metric
SW401: RST_SW; SW_SPST_B3S-1000
U401: TM4C1294NCPDTGOOD; TQFP-128_14x14mm_P0.4mm
Y401: Crystal_GND24; Crystal_SMD_3225-4Pin_3.2x2.5mm
Y402: Crystal; Crystal_SMD_MicroCrystal_CC7V-T1A-2Pin_3.2x1.5mm

Connections:
+3V3: C403.1, C405.1, C407.1, C409.1, C414.1, C415.1, C416.1, D405.2 (A), R2.2, R405.2, R409.1, R410.1, R411.1, R412.1, U401.7 (VDD@11), U401.8 (VDDA), U401.9 (VREFA+), U401.16 (VDD@3), U401.26 (VDD@4), U401.28 (VDD@5), U401.39 (VDD@6), U401.47 (VDD@7), U401.51 (VDD@8), U401.52 (VDD@9), U401.69 (VDD@10), U401.79 (VDD@12), U401.90 (VDD@13), U401.101 (VDD), U401.113 (VDD@1), U401.122 (VDD@2); also elsewhere on the board
/Connectors/JTAG_TCK: U401.100 (PC0); also elsewhere on the board
/Connectors/JTAG_TDI: U401.98 (PC2); also elsewhere on the board
/Connectors/JTAG_TDO: U401.97 (PC3); also elsewhere on the board
/Connectors/JTAG_TMS: U401.99 (PC1); also elsewhere on the board
/Connectors/USB_OTG_VBUS: U401.96 (PB1); also elsewhere on the board
/Connectors/~ENABLE: U401.31 (PH2); also elsewhere on the board
/Connectors/~INHIBIT: U401.32 (PH3); also elsewhere on the board
/Connectors/~SYSRESET: U401.30 (PH1); also elsewhere on the board
/Memory/EPI0S0: U401.18 (PK0); also elsewhere on the board
/Memory/EPI0S1: U401.19 (PK1); also elsewhere on the board
/Memory/EPI0S2: U401.20 (PK2); also elsewhere on the board
/Memory/EPI0S3: U401.21 (PK3); also elsewhere on the board
/Memory/EPI0S4: U401.22 (PC7); also elsewhere on the board
/Memory/EPI0S5: U401.23 (PC6); also elsewhere on the board
/Memory/EPI0S6: U401.24 (PC5); also elsewhere on the board
/Memory/EPI0S7: U401.25 (PC4); also elsewhere on the board
/Memory/EPI0S8: U401.40 (PA6); also elsewhere on the board
/Memory/EPI0S9: U401.41 (PA7); also elsewhere on the board
/Memory/EPI0S10: U401.50 (PG1); also elsewhere on the board
/Memory/EPI0S11: U401.49 (PG0); also elsewhere on the board
/Memory/EPI0S12: U401.75 (PM3); also elsewhere on the board
/Memory/EPI0S13: U401.76 (PM2); also elsewhere on the board
/Memory/EPI0S14: U401.77 (PM1); also elsewhere on the board
/Memory/EPI0S15: U401.78 (PM0); also elsewhere on the board
/Memory/EPI0S16: U401.81 (PL0); also elsewhere on the board
/Memory/EPI0S17: U401.82 (PL1); also elsewhere on the board
/Memory/EPI0S18: U401.83 (PL2); also elsewhere on the board
/Memory/EPI0S19: U401.84 (PL3); also elsewhere on the board
/Memory/EPI0S28: U401.92 (PB3); also elsewhere on the board
/Memory/EPI0S31: U401.62 (PK5); also elsewhere on the board
/Memory/FLASH_DAT0: U401.2 (PD1); also elsewhere on the board
/Memory/FLASH_DAT1: U401.1 (PD0); also elsewhere on the board
/Memory/FLASH_DAT2: U401.128 (PD7); also elsewhere on the board
/Memory/FLASH_DAT3: U401.127 (PD6); also elsewhere on the board
/Memory/FLASH_SCLK: U401.4 (PD3); also elsewhere on the board
/TM4C129/ETH_LED0: D401.2 (A), U401.42 (PF0)
/TM4C129/ETH_LED0_CATHODE: D401.1 (K), R407.2
/TM4C129/ETH_LED1: D402.2 (A), U401.46 (PF4)
/TM4C129/ETH_LED1_CATHODE: D402.1 (K), R408.2
/TM4C129/ETH_RXI_N: R412.2, U401.53 (EN0RXIN); also elsewhere on the board
/TM4C129/ETH_RXI_P: R411.2, U401.54 (EN0RXIP); also elsewhere on the board
/TM4C129/ETH_TXO_N: R410.2, U401.56 (EN0TXON); also elsewhere on the board
/TM4C129/ETH_TXO_P: R409.2, U401.57 (EN0TXOP); also elsewhere on the board
/TM4C129/OSC0: C401.1, U401.88 (OSC0), Y401.1
/TM4C129/OSC1: R403.1, U401.89 (OSC1)
/TM4C129/OSC1_R: C402.2, R403.2, Y401.3
/TM4C129/PWR_LED_CATHODE: D405.1 (K), R415.2
/TM4C129/R_BIAS: R404.1, U401.59 (RBIAS)
/TM4C129/SSI2Fss: U401.3 (PD2); also elsewhere on the board
/TM4C129/UART_DEBUG_RXD: U401.33 (PA0); also elsewhere on the board
/TM4C129/UART_DEBUG_TXD: U401.34 (PA1); also elsewhere on the board
/TM4C129/USB_D_N: U401.93 (PL7); also elsewhere on the board
/TM4C129/USB_D_P: U401.94 (PL6); also elsewhere on the board
/TM4C129/USB_ID: R402.2; also elsewhere on the board
/TM4C129/USB_ID_R: R402.1, U401.95 (PB0)
/TM4C129/USER_LED0: D403.2 (A), U401.107 (PN0)
/TM4C129/USER_LED0_CATHODE: D403.1 (K), R413.2
/TM4C129/USER_LED1: D406.2 (A), U401.108 (PN1)
/TM4C129/USER_LED1_CATHODE: D406.1 (K), R416.2
/TM4C129/USER_LED2: D404.2 (A), U401.109 (PN2)
/TM4C129/USER_LED2_CATHODE: D404.1 (K), R414.2
/TM4C129/USER_LED3: D407.2 (A), U401.110 (PN3)
/TM4C129/USER_LED3_CATHODE: D407.1 (K), R417.2
/TM4C129/VBat_R: R1.1, R2.1, U401.68 (VBAT)
/TM4C129/VDDC: C404.1, C406.1, C408.1, U401.87 (VDDC@1), U401.115 (VDDC)
/TM4C129/V_Batt/Vout: R1.2; also elsewhere on the board
/TM4C129/XOSC0: C412.1, U401.66 (XOSC0), Y402.1
/TM4C129/XOSC1: C411.2, U401.67 (XOSC1), Y402.2
/TM4C129/~RST: C413.1, R405.1, R406.1, U401.70 (RST)
GND: C401.2, C402.1, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C411.1, C412.2, C413.2, C414.2, C415.2, C416.2, R404.2, R407.1, R408.1, R413.1, R414.1, R415.1, R416.1, R417.1, SW401.1, U401.10 (GNDA), U401.17 (GND@1), U401.48 (GND@2), U401.55 (GND@3), U401.58 (GND@4), U401.64 (WAKE), U401.80 (GND@5), U401.114 (GND), Y401.2, Y401.4; also elsewhere on the board
unnamed: R406.2, SW401.2

Notes on the sheet:
EPI0S31 should be configured for 12mA drive. The rest of the EPI signals can be 8mA drive.
VDDC Decoupling cap should total 3.3uF to 3.4uF
Bulk Cap should total 2.2uF to 22uF
Ethernet Pull-up Resistors
Ethernet and User-Defined LEDs
Place Decoupling caps close to power pairs
RC time circuit to meet ontime requirements

Schematic: USB_to_UART.sch, Raptor2000

Parts:
C501: 0.1u; C_0603_1608Metric
C502: 100nF; C_0603_1608Metric
C503: 3300pF; C_0603_1608Metric
D501, D502: LED; LED_0805_2012Metric
J501: USB_B_Micro; USB_Micro-B_Molex-105017-0001
R501, R502: 330; R_0603_1608Metric
R503: 4.7k; R_0603_1608Metric
R504: 10k; R_0603_1608Metric
R505: 1M; R_0603_1608Metric
U501: FT232RL; SSOP-28_5.3x10.2mm_P0.65mm

Connections:
+3V3: C501.2, U501.4; also elsewhere on the board
+5V: U501.20; also elsewhere on the board
/TM4C129/UART_DEBUG_RXD: U501.1; also elsewhere on the board
/TM4C129/UART_DEBUG_TXD: U501.5; also elsewhere on the board
/USB_to_UART/DBG_USB_D_N: J501.2, U501.16
/USB_to_UART/DBG_USB_D_P: J501.3, U501.15
/USB_to_UART/DBG_USB_SHIELD: C503.1, J501.5, R505.1
/USB_to_UART/DBG_VBUS: J501.1, R503.1
/USB_to_UART/USB_LED_0: D501.2 (A), U501.23
/USB_to_UART/USB_LED_1: D502.2 (A), U501.22
GND: C501.1, C502.2, C503.2, J501.4, J501.6, R501.2, R502.2, R504.2, R505.2, U501.7, U501.18, U501.21, U501.25, U501.26; also elsewhere on the board
unnamed: C502.1, U501.17
unnamed: D501.1 (K), R501.1
unnamed: D502.1 (K), R502.1
unnamed: R503.2, R504.1, U501.19

Schematic: v_batt.sch

Parts:
C1: 0.1u; C_0603_1608Metric
C2: 10u; C_0603_1608Metric
U1: LT1761-3; TSOT-23-5

Connections:
+BATT: U1.1, U1.3; also elsewhere on the board
/TM4C129/V_Batt/Vout: C1.1, C2.1, U1.5; also elsewhere on the board
GND: C2.2, U1.2; also elsewhere on the board
unnamed: C1.2, U1.4

Board: 4 copper layers, 63.5 x 76.2 mm, 80 parts (19 on the bottom side), 86 nets.

Other parts of the board:
C3: 1u; C_0603_1608Metric

Their connections:
+BATT: C3.1; also elsewhere on the board
GND: C3.2; also elsewhere on the board

## Commit log

2019-05-05 initial commit for raptor2000 sbc
2019-05-05 adding schematic pdf
2019-05-25 fixing some unnamed nets.
2019-05-31 Create LICENSE
2019-06-02 Connected the board sense pin to 3.3V to work with the backplane.
2019-06-05 Added usb id and usb vbus pins to tm4c circuit. Unconnected on main backplane connector.
2019-06-06 Changed USB ID and VBUS resistors.
2019-06-20 initial implementation of vbatt for RTC.
2019-06-22 added nand flash, removed sd card. finished rtc circuit. added leds
2019-06-22 added component values for RAM decoupling caps
2019-06-22 updated schematic pdf
2019-06-23 fixed misnamed EPI nets.
2019-06-23 fixed component value for decoupling cap on nand flash.
2019-06-23 added a note about EPI signal drive strength.
2019-06-23 updating sch pdf
2019-06-23 updated come component values.
2019-06-23 added reset button and pullup. Moved sysreset to a gpio pin.
2019-06-23 added a debug microusb port.
2019-06-24 Fixed some componenet values. Added some layout notes. added decoupling cap to usb-to-uart circuit.
2019-06-25 adding netlist
2019-06-29 added part footprints. added usb-uart leds.
2019-06-29 added rtc battery footprint
2019-06-29 updated netlist
2019-07-02 regenerated netlist/annotations and refdeses. using new connector symbol.
2019-07-13 started layout. fixing some netnames.
2019-07-14 replaced battery with ldo connected to external vbatt. Layout passes DRC
2019-07-14 moved ldo vbatt circuit to a sheet
2019-07-16 removed rc filter on vbatt output. Included ltspice sim to prove it's unneeded.
2019-07-20 sourced all parts, except LEDs. added bom. fixed a few footprints/values.
2019-07-20 bom fix
2019-07-21 layout and schematic cleanup.
2019-07-21 layout cleanup, updating pdf.
2019-07-23 finished layout. generated gerbers.
2019-07-23 added board/company name
